# Keil uVision project RI-tag.uvprojx, settings and files
target nrf51822_xxAA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RI-tag +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF51822 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: .\Source;..\..\SDK12.2\components\toolchain;..\..\SDK12.2\components\toolchain\arm;..\..\SDK12.2\components\toolchain\cmsis\include;..\..\SoftDevices\s130_nrf51_2.0.1\s130_nrf51_2.0.1_API\include;..\..\SoftDevices\s130_nrf51_2.0.1\s130_nrf51_2.0.1_API\include\nrf51;..\..\SDK12.2\components\device;..\..\SDK12.2\components\libraries\util;..\..\SDK12.2\components\drivers_nrf\delay;..\..\SDK12.2\components\drivers_nrf\gpiote;..\..\SDK12.2\components\drivers_nrf\hal;.\BLE400;..\..\SDK12.2\components\libraries\log;..\..\SDK12.2\components\libraries\log\src;..\..\SDK12.2\components\libraries\util;..\..\SDK12.2\components\ble\ble_services\ble_dis;..\..\SDK12.2\components\ble\common;..\..\SDK12.2\components\softdevice\common\softdevice_handler;..\..\SDK12.2\components\drivers_nrf\clock;..\..\SDK12.2\components\drivers_nrf\common;..\..\SDK12.2\components\drivers_nrf\timer;..\..\SDK12.2\components\libraries\timer;..\..\SDK12.2\components\ble\ble_advertising;..\..\SDK12.2\components\libraries\fstorage;..\..\SDK12.2\components\libraries\experimental_section_vars;.\Segger;..\..\SDK12.2\components\drivers_nrf\rtc;..\..\SDK12.2\components\ble\ble_radio_notification
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DS130,-DNRF_SD_BLE_API_VERSION=2,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002500 size 0x2500
  group Source
    ./Source/: main.c main.h nrf51_tag_uart.c nrf51_tag_uart.h nrf51_tag_debug.c nrf51_tag_debug.h nrf51_tag_error.c nrf51_tag_error.h nrf51_tag_version.c nrf51_tag_version.h nrf51_tag_tx_power.c nrf51_tag_tx_power.h nrf51_tag_power_manage.c nrf51_tag_power_manage.h nrf51_tag_initialize.c nrf51_tag_initialize.h nrf51_tag_ble_stack.c nrf51_tag_ble_stack.h nrf51_tag_gap_params.c nrf51_tag_gap_params.h nrf51_tag_connection_parameters.c nrf51_tag_connection_parameters.h nrf51_tag_timers.c nrf51_tag_timers.h nrf51_tag_radio_notification.c nrf51_tag_radio_notification.h nrf51_tag_security_parameters.c nrf51_tag_security_parameters.h nrf51_tag_terminate_connection.c nrf51_tag_terminate_connection.h nrf51_tag_connection_settings.c nrf51_tag_connection_settings.h nrf51_tag_connection_security.c nrf51_tag_connection_security.h nrf51_tag_advertising.c nrf51_tag_advertising.h nrf51_tag_whitelist.c nrf51_tag_whitelist.h nrf51_tag_on_ble_evt.c nrf51_tag_on_ble_evt.h nrf51_tag_dbg_ble_on_evt.c nrf51_tag_dbg_ble_on_evt.h nrf51_tag_authentication_status.c nrf51_tag_authentication_status.h nrf51_tag_on_ble_evt_gap.c nrf51_tag_on_ble_evt_gap.h nrf51_tag_on_ble_evt_gatt.c nrf51_tag_on_ble_evt_gatt.h nrf51_tag_on_ble_evt_sd.c nrf51_tag_on_ble_evt_sd.h nrf51_tag_rtc.c nrf51_tag_rtc.h nrf51_tag_spi0_lis3dh.c nrf51_tag_spi0_lis3dh.h
  group Tag Services
    ./Source/: nrf51_tag_services_init.c nrf51_tag_services_init.h nrf51_tag_debug_cmd_characteristic.c nrf51_tag_debug_service.c nrf51_tag_debug_service.h nrf51_tag_debug_cmd_gatt.c nrf51_tag_status_characteristic.c nrf51_tag_status_gatt.c nrf51_tag_status_service.c nrf51_tag_status_service.h nrf51_tag_configuration_characteristic.c nrf51_tag_configuration_gatt.c nrf51_tag_configuration_service.c nrf51_tag_configuration_service.h nrf51_tag_activity_log_characteristic.c nrf51_tag_activity_log_gatt.c nrf51_tag_activity_log_service.c nrf51_tag_activity_log_service.h
  group Headers
    ./Source/: sdk_config.h nrf51_sys_defines.h nrf51_std_headers.h nrf51_sys_headers.h nrf51_ble_headers.h nrf51_tag_headers.h
  group Startup
    ../../SDK12.2/components/toolchain/: system_nrf51.c system_nrf51.h
    ../../SDK12.2/components/toolchain/arm/: arm_startup_nrf51.s uicr_config.h
  group CMSIS
    ../../SDK12.2/components/toolchain/cmsis/include/: cmsis_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group nrf51_s130_2.0.1
    ../../SoftDevices/s130_nrf51_2.0.1/s130_nrf51_2.0.1_API/include/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sdm.h nrf_soc.h nrf_svc.h
    ../../SoftDevices/s130_nrf51_2.0.1/s130_nrf51_2.0.1_API/include/nrf51/: nrf_mbr.h
  group BLE400
    ./BLE400/: BLE400_utils.c BLE400_utils.h
  group nrf51822
    ../../SDK12.2/components/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51822_peripherals.h
  group Nordic_NRF
    ../../SDK12.2/components/drivers_nrf/timer/: nrf_drv_timer.h nrf_drv_timer.c
    ../../SDK12.2/components/libraries/util/: nrf_bitmask.h app_util_platform.c app_util_platform.h
    ../../SDK12.2/components/drivers_nrf/clock/: nrf_drv_clock.c nrf_drv_clock.h
    ../../SDK12.2/components/drivers_nrf/common/: nrf_drv_common.c nrf_drv_common.h
    ../../SDK12.2/components/libraries/fstorage/: fstorage.h fstorage.c
    ../../SDK12.2/components/libraries/experimental_section_vars/: section_vars.h
    ../../SDK12.2/components/drivers_nrf/rtc/: nrf_drv_rtc.c nrf_drv_rtc.h
  group Nordic_APP
    ../../SDK12.2/components/libraries/util/: app_util.h app_error.h app_error.c
    ../../SDK12.2/components/libraries/timer/: app_timer.c app_timer.h
  group NRF_Log
    ../../SDK12.2/components/libraries/log/: nrf_log.h nrf_log_backend.h nrf_log_backend_dox_config.h nrf_log_ctrl.h nrf_log_dox_config.h
    ../../SDK12.2/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_ctrl_internal.h nrf_log_frontend.c nrf_log_internal.h
  group Nordic_BLE
    ../../SDK12.2/components/ble/ble_services/ble_dis/: ble_dis.c ble_dis.h
    ../../SDK12.2/components/ble/common/: ble_srv_common.c ble_srv_common.h ble_advdata.c ble_advdata.h
    ../../SDK12.2/components/ble/ble_advertising/: ble_advertising.c ble_advertising.h
    ../../SDK12.2/components/ble/ble_radio_notification/: ble_radio_notification.c ble_radio_notification.h
  group Nordic_SoftDevice
    ../../SDK12.2/components/softdevice/common/softdevice_handler/: app_ram_base.h ble_stack_handler_types.h softdevice_handler.c softdevice_handler.h
  group Segger
    ./Segger/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
